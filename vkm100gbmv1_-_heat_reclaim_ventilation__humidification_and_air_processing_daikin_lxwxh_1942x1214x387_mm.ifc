Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-04-06T11:48:27
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - IFC Model Exchange with ARCHICAD 22.0.0.6010

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0 | Other(Type) - Category: Levels; Family Name: Level; Identity Data(Type) - Type Name: 8mm Head; Constraints - Elevation: 0 mm; Dimensions - Computation Height: 0 mm; Identity Data - Building Story: yes; Name: Level 1; Structural: no; Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head; Constraints(Type) - Elevation Base: Project Base Point; Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Level 2 | Level 2 | 4000

# IfcDistributionPort (8)
Name | FlowDirection
 | SOURCE | Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 12.7 mm; ConnectorDiameter: 12.7 mm; NominalWidth: 12.7 mm; NominalHeight: 12.7 mm
 | SINK | Pset_DistributionPortPipe - PortNumber: 2; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 6.4 mm; ConnectorDiameter: 6.4 mm; NominalWidth: 6.4 mm; NominalHeight: 6.4 mm
 | SOURCE | Pset_DistributionPortPipe - PortNumber: 3; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 19.1 mm; ConnectorDiameter: 19.1 mm; NominalWidth: 19.1 mm; NominalHeight: 19.1 mm
 | SOURCE | Pset_DistributionPortDuct - PortNumber: 4; ConnectionType: NONE; MEPPortDuct - ProfileShape: ROUND; NominalWidth: 250 mm; NominalHeight: 250 mm
 | SOURCE | Pset_DistributionPortDuct - PortNumber: 5; ConnectionType: NONE; MEPPortDuct - ProfileShape: ROUND; NominalWidth: 250 mm; NominalHeight: 250 mm
 | SINK | Pset_DistributionPortPipe - PortNumber: 6; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 6.4 mm; ConnectorDiameter: 6.4 mm; NominalWidth: 6.4 mm; NominalHeight: 6.4 mm
 | SINK | Pset_DistributionPortDuct - PortNumber: 7; ConnectionType: NONE; MEPPortDuct - ProfileShape: ROUND; NominalWidth: 250 mm; NominalHeight: 250 mm
 | SINK | Pset_DistributionPortDuct - PortNumber: 8; ConnectionType: NONE; MEPPortDuct - ProfileShape: ROUND; NominalWidth: 250 mm; NominalHeight: 250 mm

# IfcEnergyConversionDevice: vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm, RSen_57_ME_FB_ventilation - heat reclaim, humidification and air processing_daikin:vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm:365325
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.10.10.10 (Uniformat); Material: RSen_x_rgb 255 255 255 T00 pure white_gen, RSen_x_rgb 199 235 223 T00 galvanised steel plate_gen, RSen_n6_PE_black
Type - Constraints - Default Elevation: 0 mm
Type - Construction - TBQen_C_diameter_type: OD; TBQen_C_diameter_type_index: 1; TBQen_C_SOg_ME_01: standard; TBQen_C_SOg_ME_02: standard
Type - Dimensions - RSen_C_height: 387 mm; RSen_C_length: 1942 mm; RSen_C_width: 1214 mm
Type - Electrical - RSen_E_c01_apparent_power: 410 W; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: no; RSen_E_c01_load_class: Other; RSen_E_c01_number_of_poles: 1; RSen_E_c01_voltage: 230 V; TBQen_E_c01_power: 410 W; TBQen_E_c01_power_factor: 1
Type - Identity Data - Assembly Code: 57.10.10.10; Description: Heat Recovery; Manufacturer: Daikin Europe N.V.; Model: Ventilation; OmniClass Number: 23.75.35.14; OmniClass Title: Air Handling Units; RSen_C_code_article: VKM100GBMV1; RSen_C_code_ETIM: Ventilation appliance; RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC000267&classVersion=5; RSen_C_code_gtin: -; RSen_C_code_product_class: VKM-GBM; RSen_C_content_creator: © ThorbiQ; RSen_C_content_date_changed: 14/01/2021; RSen_C_content_date_issue: 14/01/2021; RSen_C_content_provider: Daikin Europe N.V.; RSen_C_content_version: 2.0.0; RSen_C_description: Heat Recovery; RSen_C_model: Ventilation; RSen_C_revit_version: 2018; RSen_C_type: Heat reclaim ventilation, humidification and air processing; RSen_C_type_comments: Indoor Unit; TBQ_I BaseKeynote: 57.10.10.10; TBQen_C_code_product: VKM100GBM; TBQen_C_IFC_version: 2x3; TBQen_C_license: Creative Commons Attribution NoDerivs (CC-ND); TBQen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; Type Comments: Indoor Unit; Type Name: vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm; URL: www.daikineurope.com
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 255 255 255 T00 pure white_gen
Type - Mechanical - TBQ_I Air flow rate_speed 1: 8.0439 m3/s; TBQ_I Air flow rate_speed 2: 9.31915 m3/s; TBQ_I Air flow rate_speed 3: 9.31915 m3/s
Type - Other - Category: Mechanical Equipment; Family Name: RSen_57_ME_FB_ventilation - heat reclaim, humidification and air processing_daikin; RSen_E_c01_description: c01_el; RSen_E_c02_description: c02_controls; RSen_M_c01_description: c01_fresh air_outdoor; RSen_M_c01_diameter: 250 mm; RSen_M_c01_height: 0 mm; RSen_M_c01_width: 0 mm; RSen_M_c02_description: c02_exhaust air; RSen_M_c02_diameter: 250 mm; RSen_M_c02_height: 0 mm; RSen_M_c02_width: 0 mm; RSen_M_c03_description: c03_supply air; RSen_M_c03_diameter: 250 mm; RSen_M_c03_height: 0 mm; RSen_M_c03_width: 0 mm; RSen_M_c04_description: c04_return air; RSen_M_c04_diameter: 250 mm; RSen_M_c04_height: 0 mm; RSen_M_c04_width: 0 mm; RSen_P_c01_description: c01_liquid piping connection; RSen_P_c01_diameter: 6.35 mm; RSen_P_c02_description: c02_gas piping connection; RSen_P_c02_diameter: 12.7 mm; RSen_P_c03_description: c03_drain piping connection; RSen_P_c03_diameter: 19.1 mm; RSen_P_c04_description: c04_feed water connection; RSen_P_c04_diameter: 6.4 mm; TBQen_E_c01_power_factor_state: Lagging; TBQen_E_c01_system_type: Power - Balanced; TBQen_E_c01_yes_no: yes; TBQen_E_c02_yes_no: yes; TBQen_M_c01_flow_configuration: Preset; TBQen_M_c01_flow_direction: In; TBQen_M_c01_loss_method: Not Defined; TBQen_M_c01_shape: Round; TBQen_M_c01_system_classification: Supply Air; TBQen_M_c01_yes_no: yes; TBQen_M_c02_flow_configuration: Preset; TBQen_M_c02_flow_direction: Out; TBQen_M_c02_loss_method: Not Defined; TBQen_M_c02_shape: Round; TBQen_M_c02_system_classification: Exhaust Air; TBQen_M_c02_yes_no: yes; TBQen_M_c03_flow_configuration: Preset; TBQen_M_c03_flow_direction: Out; TBQen_M_c03_loss_method: Not Defined; TBQen_M_c03_shape: Round; TBQen_M_c03_system_classification: Supply Air; TBQen_M_c03_yes_no: yes; TBQen_M_c04_flow_configuration: Preset; TBQen_M_c04_flow_direction: In; TBQen_M_c04_loss_method: Not Defined; TBQen_M_c04_shape: Round; TBQen_M_c04_system_classification: Return Air; TBQen_M_c04_yes_no: yes; TBQen_P_c01_diameter_calc: 6.4 mm; TBQen_P_c01_flow_configuration: Preset; TBQen_P_c01_flow_direction: In; TBQen_P_c01_loss_method: Not Defined; TBQen_P_c01_system_classification: Hydronic Supply; TBQen_P_c01_yes_no: yes; TBQen_P_c02_diameter_calc: 12.7 mm; TBQen_P_c02_flow_configuration: Preset; TBQen_P_c02_flow_direction: Out; TBQen_P_c02_loss_method: Not Defined; TBQen_P_c02_system_classification: Hydronic Return; TBQen_P_c02_yes_no: yes; TBQen_P_c03_diameter_calc: 19.1 mm; TBQen_P_c03_flow_configuration: Fixture Units; TBQen_P_c03_flow_direction: Out; TBQen_P_c03_loss_method: Not Defined; TBQen_P_c03_system_classification: Sanitary; TBQen_P_c03_yes_no: yes; TBQen_P_c04_diameter_calc: 6.4 mm; TBQen_P_c04_flow_configuration: Preset; TBQen_P_c04_flow_direction: In; TBQen_P_c04_loss_method: Not Defined; TBQen_P_c04_system_classification: Domestic Cold Water; TBQen_P_c04_yes_no: yes
Pset_ManufacturerTypeInformation - Manufacturer: Daikin Europe N.V.
Pset_DistributionFlowElementCommon - Reference: vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm
Constraints - Elevation: 0 mm; Host: Reference Plane : h_rightleft
Construction - TBQen_C_alignment: Center; TBQen_C_alignment_index: 0; TBQen_C_GOg: no; TBQen_C_SOg: yes; TBQen_C_suspension_height: 50 mm
Dimensions - Area: 80.3683 m2; Volume: 20.4287 m3
Graphics - TBQen_C_clearance_zone: no; TBQen_C_connection_zone: no; TBQen_C_logo: no; TBQen_C_maintenance_zone: no; TBQen_C_neighbour_unit: no; TBQen_C_neighbour_unit_displacement_back: 0 mm; TBQen_C_neighbour_unit_displacement_front: 0 mm; TBQen_C_neighbour_unit_displacement_left: 0 mm; TBQen_C_neighbour_unit_displacement_right: 0 mm
Identity Data - Mark: 29
Mechanical - RSen_M_c01_flow_rate: 8.0439 m3/s; RSen_M_c02_flow_rate: 8.0439 m3/s; RSen_M_c03_flow_rate: 8.0439 m3/s; RSen_M_c04_flow_rate: 8.0439 m3/s; RSen_P_c01_volume_flow: 0 m3/s; RSen_P_c02_volume_flow: 0 m3/s; RSen_P_c03_load_value: 0; RSen_P_c04_volume_flow: 0 m3/s; System Classification: Hydronic Return,Hydronic Supply,Sanitary,Return Air,Supply Air,Exhaust Air,Power,Domestic Cold Water,Controls
Mechanical - Flow - TBQen_M_flow_rate: 8.0439 m3/s; TBQen_M_flow_rate_index: 0; TBQen_M_flow_rate_info: Low
Other - Family: RSen_57_ME_FB_ventilation - heat reclaim, humidification and air processing_daikin: vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm; Family and Type: RSen_57_ME_FB_ventilation - heat reclaim, humidification and air processing_daikin: vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm; Type: RSen_57_ME_FB_ventilation - heat reclaim, humidification and air processing_daikin: vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm; Type Id: RSen_57_ME_FB_ventilation - heat reclaim, humidification and air processing_daikin: vkm100gbmv1 - heat reclaim ventilation, humidification and air processing_daikin_lxwxh 1942x1214x387 mm
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: https://thorbiq.freshdesk.com/support/solutions
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
